# Keil uVision project FreeRTOS-Transplant-Template.uvprojx, settings and files
target FLASH (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS-Transplant-Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=2 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Core;..\FWLIB\inc;..\User;..\System\SYS;..\System\delay;..\Hardware\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\System\usart;..\Hardware\OLED;..\Software\iic;..\System\timer;..\System\bkp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/Startup/: startup_stm32f10x_md.s
  group FwLib
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group System
    ../System/SYS/: sys.c
    ../System/delay/: delay.c
    ../System/usart/: usart.c
  group Hardware
    ../Hardware/LED/: led.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
